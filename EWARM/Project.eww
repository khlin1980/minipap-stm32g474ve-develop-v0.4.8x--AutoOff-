<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32G474VE_OC_RTOS.ewp</path>
  </project>
  <batchBuild />
</workspace>
